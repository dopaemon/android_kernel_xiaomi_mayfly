## drivers/misc/perf_helper/Kconfig
```kconfig
config PERF_HELPER
        tristate "Perf helper"
        default y
        help
          this module support some base functions for performance.
```
